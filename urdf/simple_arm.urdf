Commit message: pidOptimization 0.1

File: urdf/simple_arm.urdf (robot description, URDF)
Before this commit: robot simple_arm, 6 links, 5 joints
Links:
- link base_link: mass 30 -> 500
